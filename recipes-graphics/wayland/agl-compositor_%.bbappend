# AGL_BRANCH = "master"
# SRCREV = "${AUTOREV}"