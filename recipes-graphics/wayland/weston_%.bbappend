PACKAGECONFIG:remove = "vnc"
PACKAGECONFIG:append = " pipewire"
