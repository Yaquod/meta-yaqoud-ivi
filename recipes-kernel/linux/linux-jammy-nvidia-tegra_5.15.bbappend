FILESEXTRAPATHS:prepend := "${THISDIR}/linux-jammy-nvidia-tegra-5.15:"
SRC_URI:append = " file://vkms.cfg"
